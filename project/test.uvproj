# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c Conf_tny.A51 CPrintf.h
  group HMI
    ./HMI/: cmd_process.c cmd_queue.c hmi_driver.c hmi_user_uart.c
  group UILogic
    ./UILogic/: actionPage.c backflowPage.c calibrationPage.c mainPage.c managerment.c pausePage.c project.c projectEditPage.c projectPage.c purgePage.c runningPage.c selectPumpPage.c tips1Page.c tips2Page.c informationPage.c
  group Peripheral
    ./Peripheral/: io.c uart.c stepmotor.c dcmotor.c sensor.c 24cxx.c myiic.c
